<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rsu_receiver</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>DSRC RSU Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation_rate</value></param>
<param><key>value</key><value>int(usrp_samples_per_second / input_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>input_rate</value></param>
<param><key>value</key><value>int(samp_per_symb * symbol_per_second)</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>lowpass_coeff</value></param>
<param><key>cutoff_freq</key><value>100e3</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>input_rate</value></param>
<param><key>width</key><value>100e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_symb</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>subcarrier_freq</value></param>
<param><key>value</key><value>1.5e6</value></param>
<param><key>label</key><value>Subcarrier frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_per_second</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_samples_per_second</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>binary_slicer</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>channel_filter</value></param>
<param><key>center_freq</key><value>5.8e9 + subcarrier_freq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>input_rate</value></param>
<param><key>taps</key><value>lowpass_coeff</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>complex_to_real</value></param>
</block>
<block>
<key>digital_mpsk_receiver_cc</key>
<param><key>id</key><value>digital_mpsk_receiver_cc_0</value></param>
<param><key>gain_mu</key><value>0.05</value></param>
<param><key>gain_omega</key><value>(samp_per_symb * samp_per_symb) / 4</value></param>
<param><key>w</key><value>cmath.pi/100.0</value></param>
<param><key>M</key><value>2</value></param>
<param><key>fmax</key><value>0.00393</value></param>
<param><key>fmin</key><value>-0.00393</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>samp_per_symb</value></param>
<param><key>theta</key><value>0</value></param>
</block>
<block>
<key>dsrcmod_nrzi_to_nrz_bb</key>
<param><key>id</key><value>dsrcmod_nrzi_to_nrz_bb_0</value></param>
<param><key>preload</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink</value></param>
<param><key>file</key><value>binary_nrz_data</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>gr.sizeof_char</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_data</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>binary_nrzi_data.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>gr.sizeof_char</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_filtered_samples</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>complex_filtered_samples.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>gr.sizeof_gr_complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_samples</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>complex_raw_samples.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>gr.sizeof_gr_complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_symbols</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>complex_symbols.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>gr.sizeof_gr_complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>file_source</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>raw_input_samples.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>gr.sizeof_gr_complex*1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>256</value></param>
<param><key>srate</key><value>input_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>usrp_source</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>5.8e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>input_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>binary_slicer</source_block_id><sink_block_id>dsrcmod_nrzi_to_nrz_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>binary_slicer</source_block_id><sink_block_id>file_sink_data</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_filter</source_block_id><sink_block_id>digital_mpsk_receiver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_filter</source_block_id><sink_block_id>file_sink_filtered_samples</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>complex_to_real</source_block_id><sink_block_id>binary_slicer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_mpsk_receiver_cc_0</source_block_id><sink_block_id>complex_to_real</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_mpsk_receiver_cc_0</source_block_id><sink_block_id>file_sink_symbols</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsrcmod_nrzi_to_nrz_bb_0</source_block_id><sink_block_id>file_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>file_source</source_block_id><sink_block_id>channel_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>channel_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>file_sink_samples</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
